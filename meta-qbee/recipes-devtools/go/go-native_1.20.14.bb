require go-${PV}.inc

require go-native.inc
