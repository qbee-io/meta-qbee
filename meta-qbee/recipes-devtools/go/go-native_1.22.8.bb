require recipes-devtools/go/go-${PV}.inc

require go-native.inc
