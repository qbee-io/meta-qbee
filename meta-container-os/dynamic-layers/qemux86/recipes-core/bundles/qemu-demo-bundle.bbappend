FILESEXTRAPATHS:prepend := "${THISDIR}/files:"


SRC_URI += " \
	file://post-install.sh \
"
